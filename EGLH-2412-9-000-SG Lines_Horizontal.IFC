Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Horizontal\EGLH-2412-9-000-SG Lines_Horizontal.IFC
Time: 2024-11-05T12:37:18+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 25.4016000000000908; Volume Measure: 0.0254016000000001; Area Measure: 5.9598882071561272

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 25.4016000000000908; Volume Measure: 0.0254016000000001; Area Measure: 5.9598882071561272

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 25.4016000000000908; Volume Measure: 0.0254016000000001; Area Measure: 5.9598882071561272

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLH-2412-9-000-SG Lines_Horizontal | PSet_Mass_Property - Mass Measure: 25.4016000000000908; Volume Measure: 0.0254016000000001; Area Measure: 5.9598882071561272
EGLH-2412-9-000-SG Lines_Horizontal | SOLIDWORKS Custom Properties - Description: LINES_HORIZONTAL; PartNo: EGLH-2412-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
