Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Horizontal\EGLH-2812-12-000-SG Lines_Horizontal.IFC
Time: 2024-11-05T12:38:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 39.7152000000003724; Volume Measure: 0.0397152000000004; Area Measure: 6.9748029083488152

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 39.7152000000003724; Volume Measure: 0.0397152000000004; Area Measure: 6.9748029083488152

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 39.7152000000003724; Volume Measure: 0.0397152000000004; Area Measure: 6.9748029083488152

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLH-2812-12-000-SG Lines_Horizontal | PSet_Mass_Property - Mass Measure: 39.7152000000003724; Volume Measure: 0.0397152000000004; Area Measure: 6.9748029083488152
EGLH-2812-12-000-SG Lines_Horizontal | SOLIDWORKS Custom Properties - Description: LINES_HORIZONTAL; PartNo: EGLH-2812-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
