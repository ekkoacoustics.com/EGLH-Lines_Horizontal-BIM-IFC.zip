Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Horizontal\EGLH-66-12-000-DG Lines_Horizontal.IFC
Time: 2024-11-05T12:36:33+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 3.9672000000000023; Volume Measure: 0.0039672000000000; Area Measure: 0.7809767270872089

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 3.9672000000000023; Volume Measure: 0.0039672000000000; Area Measure: 0.7809767270872089

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 3.9672000000000023; Volume Measure: 0.0039672000000000; Area Measure: 0.7809767270872089

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLH-66-12-000-DG Lines_Horizontal | PSet_Mass_Property - Mass Measure: 3.9672000000000023; Volume Measure: 0.0039672000000000; Area Measure: 0.7809767270872089
EGLH-66-12-000-DG Lines_Horizontal | SOLIDWORKS Custom Properties - Description: LINES_HORIZONTAL; PartNo: EGLH-2812-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
